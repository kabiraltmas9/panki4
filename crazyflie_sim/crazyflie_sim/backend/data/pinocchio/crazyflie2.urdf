Commit message: Resolved

File: crazyflie_sim/crazyflie_sim/backend/data/pinocchio/crazyflie2.urdf (robot description, URDF)
Before this commit: robot crazflie, 2 links, 1 joints
Links:
- link base: geometry collision sphere radius=0.1
