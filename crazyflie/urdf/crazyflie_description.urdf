Commit message: update URDF

File: crazyflie/urdf/crazyflie_description.urdf (robot description, URDF)
Before this commit: robot $NAME, 1 links, 0 joints
Links:
- link $NAME: geometry visual mesh filename=package://crazyflie/urdf/cf2_assembly_with_props.dae scale=1.0 1.0 1.0
